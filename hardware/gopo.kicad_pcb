# Repository gokcesena53/usb-pd-power-supply (continued)

## KiCad design hardware/gopo.kicad_pcb (continued)

Board: 4 copper layers, 144 parts (94 on the bottom side), 86 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
MECH_ENC: PANEL EC1121S; J9 cable

File hardware/docs/output/BOM_OZDISAN_REV_C_20260921.xlsx (part):

Referanslar | Adet | Değer | Kılıf (tasarım) | Tasarım MPN | Seçilen Özdisan MPN | Üretici | Özdisan açıklaması | Özdisan kodu | Stok | MOQ | Sipariş katı | Sipariş adedi | Birim fiyat (TRY) | Satır toplamı (TRY) | Durum | Seçim kaynağı | Not | Özdisan bağlantısı
U1 | 1 | AP33772SDKZ-13-FA02 | WQFN-24 4x4 | AP33772SDKZ-13-FA02 |  |  |  |  |  |  |  |  |  |  | Stokta yok | Tasarım MPN'i | Özdisan indeksinde (stoksuz dahil) bulunamadı. Başka tedarikçiden alınmalı.
U2 | 1 | ESP32-C6-WROOM-1 | WROOM-1 modül | ESP32-C6-WROOM-1 |  |  |  |  |  |  |  |  |  |  | Stokta yok | Tasarım MPN'i | 21.09 üçüncü tur: ESP32-C6 modülü Özdisan'da yok; özellikleri karşılayan muadil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
U3 | 1 | INA226 | VSSOP-10 (DGS) | INA226AIDGSR | INA226AIDGSR | TEXAS | IC-226 MONITOR PWR/CURR BIDIR | 640350 | 9865 | 1 | 1 | 1 | 80.4401 | 80.44 | Uygun | Önceden seçilmiş | Seçim raporu: design_decisions/reports/ina226-20260921. | https://www.ozdisan.com/p/akim-yonetimi-entegreleri-273/texa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
U4 | 1 | BQ32000 | SOIC-8 (C7 SON-8'den) | BQ32000DR | BQ32000DR | TEXAS | IC-32000 SRL REAL TIME CLOCK SOIC8 | 467622 | 8985 | 1 | 1 | 1 | 39.4798 | 39.48 | Uygun | Yeni seçildi | 21.09 RTC revizyonu: RV-3028-C7 yerine BQ32000DR (kullanıcı kararı). VCC 3,0–3,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 | https://www.ozdisan.com/p/gercek-zamanli-saat-entegreleri-21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
U5 | 1 | AOZ1284PI | SOIC-8-EP | AOZ1284PI | AOZ1284PI | ALPHA&OMEGA | IC-1284 REG BUCK ADJ 4A 8SO | 594873 | 6659 | 1 | 1 | 1 | 47.1726 | 47.17 | Uygun | Önceden seçilmiş | Şemada 'Tedarik: Ozdisan' notu var. | https://www.ozdisan.com/p/dc-dc-voltaj-regulatorleri-275/alp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
U6 | 1 | TL431BIDBZR | SOT-23 | TL431BIDBZR | TL431AIDBZR | TEXAS | IC-431 REFERENCE +2.5..36V SOT23-3 | 341981 | 2428 | 1 | 1 | 1 | 6.41547 | 6.42 | Muadil | Yeni seçildi | B sınıfı (%0,5) stokta yok. Aynı TI DBZ pin dizilişli A sınıfı (%1) seçildi; V_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 | https://www.ozdisan.com/p/voltaj-referans-entegreleri-287/te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
U10 | 1 | TPD4EUSB30 | USON-10 | TPD4EUSB30 |  |  |  |  |  |  |  |  |  |  | Stokta yok | Tasarım MPN'i | Stokta yok. Stoktaki TPD4E1U06DBVR / TPD4E001DBVR SOT-23-6 kılıflı; kullanmak f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
U11 | 1 | TPS55340PWPR | HTSSOP-14 | TPS55340PWPR | TPS55340PWPR | TEXAS | IC-55340 REG BOOST ADJ 5.25A 14HTSSOP | 645605 | 449 | 1 | 1 | 1 | 96.1498 | 96.15000000000001 | Uygun | Tasarım MPN'i |  | https://www.ozdisan.com/p/dc-dc-voltaj-regulatorleri-275/tex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
U12 | 1 | AP74502Q | TSOT-23-8 | AP74502Q |  |  |  |  |  |  |  |  |  |  | Stokta yok | Tasarım MPN'i | İdeal diyot kategorisi indekste; parça yok. Stokta yalnız LM74610/LM74801/TPS21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
Q1,Q2 | 2 | BSS138 | SOT-23 | BSS138 | BSS138P,215 | NEXPERIA | MOSFET 360mA 60V N-CH SOT23 | 737689 | 73553 | 5 | 5 | 5 | 2.25609 | 11.28 | Uygun | Yeni seçildi | Jenerik BSS138 karşılığı; 60V / 360mA, SOT-23 G-S-D. | https://www.ozdisan.com/p/discrete-mosfetler-435/nexperia-bs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
Q3,Q5 | 2 | SQJB60EP | PowerPAK SO-8L Dual | SQJB60EP-T1_GE3 | SQJB60EP-T1_GE3 | VISHAY SILICONIX | MOSFET 30A 60V N-CH POWERPAK SO-8 | 700940 | 107664 | 1 | 1 | 2 | 38.5753 | 77.15000000000001 | Uygun | Önceden seçilmiş | Seçim raporu: design_decisions/reports/sqjb60ep-20260921. Footprint henüz atanm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 | https://www.ozdisan.com/p/discrete-mosfetler-435/vishay-sili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
D2 | 1 | SS2060FL | SOD-123F | SS2060FL_R1_00001 | SS2060FL_R1_00001 | PANJIT | SCHOTTKY 2A 60V SOD123FL | 574723 | 51111 | 2 | 2 | 2 | 2.88212 | 5.76 | Uygun | Önceden seçilmiş |  | https://www.ozdisan.com/p/schottky-diyotlar-385/panjit-ss206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
D3,D7 | 2 | SMBJ30A | SMB (DO-214AA) | SMBJ30A | SMBJ30A-E3/52 | VISHAY | TVS 600W 30V SMB Uni | 507320 | 15956 | 2 | 2 | 2 | 4.31596 | 8.630000000000001 | Uygun | Yeni seçildi | Şema açıklaması '400W / SMA' diyor ama footprint SMB; SMB/600W parça footprint'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 | https://www.ozdisan.com/p/tvs-diyotlar-386/vishay-smbj30a-e3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
D4 | 1 | SS34 TBD | SMA (DO-214AC) | TBD | SX36_R1_00001 | PANJIT | SCHOTTKY 3A 60V SMA | 574842 | 437 | 2 | 2 | 2 | 4.5201 | 9.039999999999999 | Uygun | Yeni seçildi | SS34 Özdisan'da yalnız SMC kılıfta var. SMA'da 3A/60V seçildi (V_PRE ~28V için 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 | https://www.ozdisan.com/p/schottky-diyotlar-385/panjit-sx36-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
D5 | 1 | BAT54 | SOD-123 | BAT54 | BAT54T1G | ONS | SCHOTTKY 200mA 30V SOD123 Single | 614028 | 595 | 5 | 5 | 5 | 1.42727 | 7.14 | Uygun | Yeni seçildi | Otomatik MPN eşleşmesi BAT54A (çift, SOT-23) getirdi; footprint'e uyan tekli SO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 | https://www.ozdisan.com/p/schottky-diyotlar-385/ons-bat54t1g-614028
D6 | 1 | BZT52C12 | SOD-123 | BZT52C12 | BZT52-C12_R1_00001 | PANJIT | ZENER 410mW 12V SOD123 5% | 560765 | 4720 | 5 | 5 | 5 | 1.11884 | 5.59 | Uygun | Yeni seçildi |  | https://www.ozdisan.com/p/zener-diyotlar-390/panjit-bzt52-c1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
D1 | 1 | LED | 0402 | TBD | APHHS1005SURCK | KINGBRIGHT | LED SMD 0402 RED 630nm 220mcd | 708179 | 272 | 1 | 1 | 1 | 18.1675 | 18.17 | Uygun | Yeni seçildi | 21.09 ikinci kontrolde LED kategorisi indekslendi. Renk tasarımda tanımsız; R14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 | https://www.ozdisan.com/p/sinyal-ledler-tek-renkli-361/kingb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
TH1 | 1 | 10k NTC | 0402 | TSM0B103F3381RZ | TSM0B103F3381RZ | THINKING | NTC 0402 10K 1% B3380 | 509291 | 8430 | 5 | 5 | 5 | 4.86845 | 24.34 | Uygun | Önceden seçilmiş |  | https://www.ozdisan.com/p/ntc-termistorler-852/thinking-tsm0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
L1 | 1 | 22u | 7.3x7.3x4.5 | SRI0704-220M |  | CORE MASTER |  |  |  |  |  |  |  |  | Stokta yok | Önceden seçilmiş | 11.09 raporunda Özdisan stoklu seçilmişti; bugün indekste yok (aynı serinin baş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
L3 | 1 | 6u8 | 1210 (3225) | TBD | B82422H1682K000 | EPCOS (TDK) | INDUCTOR 1210 6.8UH SMD | 489001 | 10 | 1 | 1 | 1 | 19.0045 | 19 | Uyarı | Yeni seçildi | Footprint'e uyan tek parça. TPS55340 boost bobini için 1210 çip bobinin akımı (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 | https://www.ozdisan.com/p/sabit-induktorler-468/epcos-tdk-b8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
SW1,SW2 | 2 | PTS810 | PTS810 SMD | PTS810 SJS 250 SMTR LFS | PTS810 SJS 250 SMTR LFS | C&K-LITTELFUSE | SWITCH TACT 4.2x3.2 SMT | 994927 | 315791 | 1 | 1 | 2 | 10.9363 | 21.87 | Uygun | Önceden seçilmiş |  | https://www.ozdisan.com/p/tact-sivicler-485/littelfuse-ck-pt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
SW3 | 1 | EC1121S enkoder | EC1121S THT | L-KLS4-EC1121S-E5A-F12.5 | L-KLS4-EC1121S-E5A-F12.5 | KLS ELECTRONIC | ENCODER 11MM WITH SWITCH | 533942 | 1013 | 1 | 1 | 1 | 31.2392 | 31.24 | Uygun | Tasarım MPN'i | Şema sembolü/ayağı ile uyumlu olan seçildi. Ön BOM'daki L-KLS4-EC12-012424-W de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 | https://www.ozdisan.com/p/enkoderler-532/kls-electronic-l-kl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
C33 | 1 | 1F5 | Ø19 H-tipi yatay coin, P20 (CR2032 yuvası yerine) | DCL5R5155HF | DCL5R5155HF | KORCHIP | CAP.SUPER 1.5F 5.5VDC 19x6.5 20mm H Type THT | 954330 | 289 | 1 | 1 | 1 | 58.556 | 58.56 | Uygun | Yeni seçildi | 21.09 RTC revizyonu: BT1 (CR2032) yerine süper kapasitör. 5,5V anma, ESR ≤30 Ω,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 | https://www.ozdisan.com/p/elektrik-cift-katmanli-kapasitorle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
Y1 | 1 | 32.768kHz | ABS25 4-SMD 8.0x3.8 | ABS25-32.768KHZ-T | ABS25-32.768KHZ-T | ABRACON | CRYSTAL 32.768kHz 12.5pF 20PPM 8X4X2.5 SMD | 489027 | 1534 | 1 | 1 | 1 | 18.7481 | 18.75 | Uygun | Yeni seçildi | 21.09 RTC revizyonu: BQ32000 kristali: CL 12,5 pF (datasheet 10,8–13,2 pF), ESR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 | https://www.ozdisan.com/p/kristaller-508/abracon-abs25-32-76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
J3 | 1 | TFT032B018 FPC | FPC 0.5mm 30p ZIF (40p Molex'ten) | L-KLS1-242I-2.0-30-R | L-KLS1-242I-2.0-30-R | KLS ELECTRONIC | CONN.FOR TFT SMT 30PIN 0.5MM FLIP TYPE | 695049 | 1248 | 1 | 1 | 1 | 12.6162 | 12.62 | Uygun | Yeni seçildi | 22.09 TFT032B018 revizyonu: NHD-2.4 (40p Molex 54132-4062) yerine TFT032B018 iç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 | https://www.ozdisan.com/p/ffc-ve-fpc-konnektorler-716/kls-el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
Q7 | 1 | IRLML6344 | SOT-23 | IRLML6344TRPBF | IRLML6344TRPBF | INFINEON | MOSFET DIS.5A 30V N-CH SOT23 SMT | 612260 | 1274 | 1 | 1 | 1 | 5.80585 | 5.81 | Uygun | Yeni seçildi | 22.09 TFT032B018 revizyonu: Backlight düşük taraf anahtarı (BL_K), TFT_BL_PWM i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 | https://www.ozdisan.com/p/discrete-mosfetler-435/infineon-ir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
R60 | 1 | 5R6 | 0805 | TBD | CRT05J7F5R60 | VIKING | RES 0805 5.6R 5% 1/8W 100PPM | 1054409 | 90200 | 100 | 100 | 100 | 0.07325 | 7.32 | Uygun | Yeni seçildi | 22.09 TFT032B018 revizyonu: Backlight akım direnci, +3.3V → BL_A. I = (3,32 − V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 | https://www.ozdisan.com/p/smt-smd-ve-cip-direncler-194/vikin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
